VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO names
  CLASS BLOCK ;
  FOREIGN names ;
  ORIGIN -0.500 -0.500 ;
  SIZE 5.000 BY 18.500 ;
  OBS
      LAYER met4 ;
        RECT 4.000 18.800 5.500 19.000 ;
        RECT 3.700 18.500 5.500 18.800 ;
        RECT 3.500 18.000 4.000 18.500 ;
        RECT 3.500 17.500 5.500 18.000 ;
        RECT 4.000 16.800 5.500 17.000 ;
        RECT 3.700 16.500 5.500 16.800 ;
        RECT 3.500 16.000 4.000 16.500 ;
        RECT 4.500 16.000 5.000 16.500 ;
        RECT 3.700 15.700 5.500 16.000 ;
        RECT 4.000 15.500 5.500 15.700 ;
        RECT 3.500 14.800 4.500 15.000 ;
        RECT 3.500 14.500 4.800 14.800 ;
        RECT 4.400 14.400 5.500 14.500 ;
        RECT 4.500 14.100 5.500 14.400 ;
        RECT 4.400 14.000 5.500 14.100 ;
        RECT 0.500 13.500 2.500 14.000 ;
        RECT 3.500 13.700 4.800 14.000 ;
        RECT 3.500 13.500 4.500 13.700 ;
        RECT 2.000 12.000 2.500 13.000 ;
        RECT 0.500 11.500 2.500 12.000 ;
        RECT 4.000 11.800 5.500 12.000 ;
        RECT 3.700 11.500 5.500 11.800 ;
        RECT 3.500 11.000 4.000 11.500 ;
        RECT 1.000 10.800 2.500 11.000 ;
        RECT 0.700 10.500 2.500 10.800 ;
        RECT 3.500 10.500 5.500 11.000 ;
        RECT 0.500 10.000 1.000 10.500 ;
        RECT 1.500 10.000 2.000 10.500 ;
        RECT 0.700 9.700 2.500 10.000 ;
        RECT 4.000 9.800 5.500 10.000 ;
        RECT 1.000 9.500 2.500 9.700 ;
        RECT 3.700 9.500 5.500 9.800 ;
        RECT 3.500 9.000 4.000 9.500 ;
        RECT 4.500 9.000 5.000 9.500 ;
        RECT 3.700 8.700 5.500 9.000 ;
        RECT 4.000 8.500 5.500 8.700 ;
        RECT 1.000 7.800 2.500 8.000 ;
        RECT 0.700 7.500 2.500 7.800 ;
        RECT 3.500 7.500 5.500 8.000 ;
        RECT 0.500 7.000 1.000 7.500 ;
        RECT 4.500 7.000 5.000 7.500 ;
        RECT 0.500 6.500 2.500 7.000 ;
        RECT 3.500 6.500 5.500 7.000 ;
        RECT 1.000 5.800 2.500 6.000 ;
        RECT 0.700 5.500 2.500 5.800 ;
        RECT 4.000 5.500 5.500 6.000 ;
        RECT 0.500 5.000 1.000 5.500 ;
        RECT 1.500 5.000 2.000 5.500 ;
        RECT 0.700 4.700 2.500 5.000 ;
        RECT 1.000 4.500 2.500 4.700 ;
        RECT 3.500 4.500 4.500 5.500 ;
        RECT 5.000 4.500 5.500 5.500 ;
        RECT 0.500 3.800 1.500 4.000 ;
        RECT 0.500 3.500 1.800 3.800 ;
        RECT 3.500 3.500 5.500 4.000 ;
        RECT 1.400 3.400 2.500 3.500 ;
        RECT 1.500 3.100 2.500 3.400 ;
        RECT 1.400 3.000 2.500 3.100 ;
        RECT 3.500 3.000 4.000 3.500 ;
        RECT 5.000 3.000 5.500 3.500 ;
        RECT 0.500 2.700 1.800 3.000 ;
        RECT 0.500 2.500 1.500 2.700 ;
        RECT 3.500 2.500 5.500 3.000 ;
        RECT 1.000 1.800 2.500 2.000 ;
        RECT 0.700 1.500 2.500 1.800 ;
        RECT 3.500 1.900 4.500 2.000 ;
        RECT 5.000 1.900 5.500 2.000 ;
        RECT 3.500 1.800 4.600 1.900 ;
        RECT 4.900 1.800 5.500 1.900 ;
        RECT 3.500 1.500 5.500 1.800 ;
        RECT 0.500 1.000 1.000 1.500 ;
        RECT 1.500 1.000 2.000 1.500 ;
        RECT 3.500 1.000 4.000 1.500 ;
        RECT 4.500 1.300 5.200 1.500 ;
        RECT 4.500 1.000 5.000 1.300 ;
        RECT 0.700 0.700 2.500 1.000 ;
        RECT 1.000 0.500 2.500 0.700 ;
        RECT 3.500 0.500 5.500 1.000 ;
  END
END names
END LIBRARY


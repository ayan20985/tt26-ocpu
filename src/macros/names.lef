VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO names
  CLASS BLOCK ;
  FOREIGN names ;
  ORIGIN -0.500 -0.500 ;
  SIZE 5.300 BY 18.500 ;
  PIN inpin
    PORT
      LAYER met3 ;
        RECT 0.500 0.500 5.800 1.000 ;
    END
  END inpin
  OBS
      LAYER met4 ;
      RECT -0.5 -0.5 4.8 18 ;
END names
END LIBRARY

